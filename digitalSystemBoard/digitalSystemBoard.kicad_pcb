File: digitalSystemBoard/digitalSystemBoard.kicad_pcb (KiCad board)
At the start: 2 copper layers, 180 x 130 mm, 200 parts, among them J1 Barrel_Jack, J10 Conn_02x03_Odd_Even, J11 Conn_02x03_Odd_Even, J12 Conn_02x03_Odd_Even, J2 USB-B, J3 Conn_02x04_Odd_Even, J4 Conn_02x04_Odd_Even, J5 Conn_02x08_Odd_Even, J6 Conn_02x07_Odd_Even, J7 Conn_02x07_Odd_Even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

Commit message: Fix name of all device
Parts:
- R0: renamed from R78; value R -> 220
- R57: renamed from R60; value 10K -> 10k
- renumbered C6 to C0, C5 to C1, C15 to C10, C16 to C11, C17 to C12, C7 to C2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
Routing:
- net GND: track 1365.7 -> 1360.7 mm
