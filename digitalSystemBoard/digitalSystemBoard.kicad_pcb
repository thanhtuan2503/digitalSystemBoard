# Repository thanhtuan2503/digitalSystemBoard

File README.md:

# INTRODUCTION TO TICKIT VER1.0 - DIGITAL SYSTEM KIT
Item: Digital System KIT

Date: Jan 10th, 2022

Delivered to: HCMUT CE-LAB

Designed in Vietnam

<p align="center">
    3D Render Board with KiCad.
</p>

## TICKIT include all below function block: 
- PWM Generator with  microcontroller ATMEGA64A.
- Display LCD with 16x2 characters.
-  5 Buttons 12x12 mm.
- 8 Switchs 21.1x5.5 mm.
- 8 Display LEDs size 3.5x2.8 mm.
- 2 7- segment LEDs.

Product Introduction in CSE Facebook page :[ KIT thí nghiệm môn học Hệ thống số do thầy và trò Khoa KH&KTMT thiết kế và phát triển](https://www.facebook.com/2180160732207910/posts/3021461968077778/).

<p align="center">
    Some functional blocks in TICKIT.
</p>

##  What's in the Box?
1. TickLab-DSKiT 1.0 Board.

2. TickLab-DSKiT 1.0 Quick Start Guide.

3. Small Screwdriver.

## Documentations and Resources
Available for free access at https://ticklab.vn/dskit

## Getting ready
1. Make sure a 3A fuse tube is properly inserted.

2. Connect the power adapter to the power jack on the board, then turn on the power switch.

3. As soon as the board is powered up, the self-test must be started. The amber LED and 7-segment display will blink at 2Hz during the self-test so you can detect early if any LEDs are dead.

## Fatal Cautions

1. DO NOT connect any outputs to another output. Connecting an output to another one may cause circuit damage, a fire, or an explosion despite a 3A fuse installed.

2. Keep liquid or no-used metal things far away from the board to avoid making a short circuit.

## KiCad design digitalSystemBoard/digitalSystemBoard.kicad_pcb

Parts:
F0: 3A; Fuse
J0: Barrel_Jack; BarrelJack_Horizontal
PM0: Power_Module
SW0: SW_SPDT; SS-12D11

Connections:
/VCC5V: F0.1; also elsewhere on the board
GND: J0.2, J0.3, PM0.2 (GND); also elsewhere on the board
unnamed: F0.2, PM0.3 (Vout+)
unnamed: J0.1, SW0.2 (B)
unnamed: PM0.1 (Vin+), SW0.1 (A)

Parts:
LED0, LED1, LED2, LED3, LED4, LED5, LED6, LED7: LED; LED_3528; LCSC C73545
Q0, Q1, Q2, Q3, Q4, Q5, Q6, Q7: BC847; SO65P210X100-3N; LCSC C8659
R4, R7, R10, R13, R16, R19, R22, R25: 15k; R_0603_1608Metric; LCSC C100780
R5, R6, R8, R9, R11, R12, R14, R15, R17, R18, R20, R21, R23, R24, R26, R27: 2.49k; R_0603_1608Metric; LCSC C22908
R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72, R73: 330; R_0603_1608Metric; LCSC C23138
U0, U1: KCSA02-105; 7SegmentLED_LTS6760_LTS6780
U2, U3: 74LS47; DIP_16_PIN_SOCKET

Connections:
/7SEGLED_TEST_OFF: U2.4 (BI), U3.4 (BI); also elsewhere on the board
/7SEGLED_TEST_ON: U2.3 (LT), U3.3 (LT); also elsewhere on the board
/BCD_A_0: U2.7 (A); also elsewhere on the board
/BCD_A_1: U3.7 (A); also elsewhere on the board
/BCD_B_0: U2.1 (B); also elsewhere on the board
/BCD_B_1: U3.1 (B); also elsewhere on the board
/BCD_C_0: U2.2 (C); also elsewhere on the board
/BCD_C_1: U3.2 (C); also elsewhere on the board
/BCD_D_0: U2.6 (D); also elsewhere on the board
/BCD_D_1: U3.6 (D); also elsewhere on the board
/LED1: R4.2; also elsewhere on the board
/LED2: R7.2; also elsewhere on the board
/LED3: R10.2; also elsewhere on the board
/LED4: R13.2; also elsewhere on the board
/LED5: R16.2; also elsewhere on the board
/LED6: R19.2; also elsewhere on the board
/LED7: R22.2; also elsewhere on the board
/LED8: R25.2; also elsewhere on the board
/SEG_A_0: R60.2, U2.13 (a); also elsewhere on the board
/SEG_A_1: R67.2, U3.13 (a); also elsewhere on the board
/SEG_B_0: R61.2, U2.12 (b); also elsewhere on the board
/SEG_B_1: R68.2, U3.12 (b); also elsewhere on the board
/SEG_C_0: R62.2, U2.11 (c); also elsewhere on the board
/SEG_C_1: R69.2, U3.11 (c); also elsewhere on the board
/SEG_D_0: R63.2, U2.10 (d); also elsewhere on the board
/SEG_D_1: R70.2, U3.10 (d); also elsewhere on the board
/SEG_E_0: R64.2, U2.9 (e); also elsewhere on the board
/SEG_E_1: R71.2, U3.9 (e); also elsewhere on the board
/SEG_F_0: R65.2, U2.15 (f); also elsewhere on the board
/SEG_F_1: R72.2, U3.15 (f); also elsewhere on the board
/SEG_G_0: R66.2, U2.14 (g); also elsewhere on the board
/SEG_G_1: R73.2, U3.14 (g); also elsewhere on the board
/VCC5V: R6.1, R9.1, R12.1, R15.1, R18.1, R21.1, R24.1, R27.1, U0.3 (CA), U0.8 (CA), U1.3 (CA), U1.8 (CA), U2.5 (RBI), U2.16 (VCC), U3.5 (RBI), U3.16 (VCC); also elsewhere on the board
GND: Q0.2 (E), Q1.2 (E), Q2.2 (E), Q3.2 (E), Q4.2 (E), Q5.2 (E), Q6.2 (E), Q7.2 (E), R5.1, R8.1, R11.1, R14.1, R17.1, R20.1, R23.1, R26.1, U2.8 (GND), U3.8 (GND); also elsewhere on the board
unnamed: LED0.1 (K), Q0.3 (C)
unnamed: LED0.2 (A), R6.2
unnamed: LED1.1 (K), Q1.3 (C)
unnamed: LED1.2 (A), R9.2
unnamed: LED2.1 (K), Q2.3 (C)
unnamed: LED2.2 (A), R12.2
unnamed: LED3.1 (K), Q3.3 (C)
unnamed: LED3.2 (A), R15.2
unnamed: LED4.1 (K), Q4.3 (C)
unnamed: LED4.2 (A), R18.2
unnamed: LED5.1 (K), Q5.3 (C)
unnamed: LED5.2 (A), R21.2
unnamed: LED6.1 (K), Q6.3 (C)
unnamed: LED6.2 (A), R24.2
unnamed: LED7.1 (K), Q7.3 (C)
unnamed: LED7.2 (A), R27.2
unnamed: Q0.1 (B), R4.1, R5.2
unnamed: Q1.1 (B), R7.1, R8.2
unnamed: Q2.1 (B), R10.1, R11.2
unnamed: Q3.1 (B), R13.1, R14.2
unnamed: Q4.1 (B), R16.1, R17.2
unnamed: Q5.1 (B), R19.1, R20.2
unnamed: Q6.1 (B), R22.1, R23.2
unnamed: Q7.1 (B), R25.1, R26.2
unnamed: R60.1, U0.7 (A)
unnamed: R61.1, U0.6 (B)
unnamed: R62.1, U0.4 (C)
unnamed: R63.1, U0.2 (D)
unnamed: R64.1, U0.1 (E)
unnamed: R65.1, U0.9 (F)
unnamed: R66.1, U0.10 (G)
unnamed: R67.1, U1.7 (A)
unnamed: R68.1, U1.6 (B)
unnamed: R69.1, U1.4 (C)
unnamed: R70.1, U1.2 (D)
unnamed: R71.1, U1.1 (E)
unnamed: R72.1, U1.9 (F)
unnamed: R73.1, U1.10 (G)

Parts:
C0, C1, C2, C3, C4: 0.1uF; C_0603_1608Metric; LCSC C14663
D0, D1, D2, D3, D4, D5, D6, D7: LED; LED_0603_1608Metric; LCSC C72043
KEY0, KEY1, KEY2, KEY3, KEY4: ButtonFirst; Button
Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15: BC847; SO65P210X100-3N; LCSC C8659
R28, R31, R34, R37, R40, R43, R46, R49: 27k; R_0603_1608Metric; LCSC C25589
R29, R32, R35, R38, R41, R44, R47, R50: 4.7k; R_0603_1608Metric; LCSC C23162
R30, R33, R36, R39, R42, R45, R48, R51: 1.8k; R_0603_1608Metric; LCSC C103360
R52, R53, R54, R55, R56: 10k; R_0603_1608Metric; LCSC C98220
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8: IO_Switch; SS-12F44G5
U4: 74HC04; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C5590
U5: Potentiometer; RV09S

Connections:
/ADJ_CLOCK: U5.2; also elsewhere on the board
/CHANGE_CLK_SRC: C4.1, KEY4.2 (e~), KEY4.3, R56.1; also elsewhere on the board
/DOWN_CLOCK: C3.2, KEY3.2 (e~), KEY3.3, R55.1; also elsewhere on the board
/KEY0: C1.1, KEY0.2 (e~), KEY0.3, R53.1; also elsewhere on the board
/KEY1: U4.2; also elsewhere on the board
/SW1: R28.2, SW1.2; also elsewhere on the board
/SW2: R31.2, SW2.2; also elsewhere on the board
/SW3: R34.2, SW3.2; also elsewhere on the board
/SW4: R37.2, SW4.2; also elsewhere on the board
/SW5: R40.2, SW5.2; also elsewhere on the board
/SW6: R43.2, SW6.2; also elsewhere on the board
/SW7: R46.2, SW7.2; also elsewhere on the board
/SW8: R49.2, SW8.2; also elsewhere on the board
/UP_CLOCK: C2.1, KEY2.2 (e~), KEY2.3, R54.1; also elsewhere on the board
/VCC5V: R30.1, R33.1, R36.1, R39.1, R42.1, R45.1, R48.1, R51.1, R52.2, R53.2, R54.2, R55.2, R56.2, SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, SW7.1, SW8.1, U4.14 (VCC), U5.1; also elsewhere on the board
GND: C0.2, C1.2, C2.2, C3.1, C4.2, KEY0.1, KEY0.4, KEY1.1, KEY1.4, KEY2.1, KEY2.4, KEY3.1, KEY3.4, KEY4.1, KEY4.4, Q8.2 (E), Q9.2 (E), Q10.2 (E), Q11.2 (E), Q12.2 (E), Q13.2 (E), Q14.2 (E), Q15.2 (E), R29.1, R32.1, R35.1, R38.1, R41.1, R44.1, R47.1, R50.1, SW1.3, SW2.3, SW3.3, SW4.3, SW5.3, SW6.3, SW7.3, SW8.3, U4.7 (GND), U5.3; also elsewhere on the board
unnamed: C0.1, KEY1.2 (e~), KEY1.3, R52.1, U4.1
unnamed: D0.1 (K), Q8.3 (C)
unnamed: D0.2 (A), R30.2
unnamed: D1.1 (K), Q9.3 (C)
unnamed: D1.2 (A), R33.2
unnamed: D2.1 (K), Q10.3 (C)
unnamed: D2.2 (A), R36.2
unnamed: D3.1 (K), Q11.3 (C)
unnamed: D3.2 (A), R39.2
unnamed: D4.1 (K), Q12.3 (C)
unnamed: D4.2 (A), R42.2
unnamed: D5.1 (K), Q13.3 (C)
unnamed: D5.2 (A), R45.2
unnamed: D6.1 (K), Q14.3 (C)
unnamed: D6.2 (A), R48.2
unnamed: D7.1 (K), Q15.3 (C)
unnamed: D7.2 (A), R51.2
unnamed: Q8.1 (B), R28.1, R29.2
unnamed: Q9.1 (B), R31.1, R32.2
unnamed: Q10.1 (B), R34.1, R35.2
unnamed: Q11.1 (B), R37.1, R38.2
unnamed: Q12.1 (B), R40.1, R41.2
unnamed: Q13.1 (B), R43.1, R44.2
unnamed: Q14.1 (B), R46.1, R47.2
unnamed: Q15.1 (B), R49.1, R50.2

Parts:
H0, H1, H2, H3: MountingHole; Mountinghole_M3
J2, J3: Conn_02x04_Odd_Even; IDC-Header_2x04_P2.54mm_Vertical
J4, J7: Conn_02x08_Odd_Even; IDC-Header_2x08_P2.54mm_Vertical
J5, J6: Conn_02x07_Odd_Even; IDC-Header_2x07_P2.54mm_Vertical
J8, J9, J10, J11: Conn_02x03_Odd_Even; IDC-Header_2x03_P2.54mm_Vertical
R74, R75, R76, R77, R78, R79, R80, R81: 47k; R_0603_1608Metric; LCSC C98220
R82, R83, R84, R85, R86, R87, R88, R89: 10k; R_0603_1608Metric; LCSC C98220

Connections:
/CLK_OUT: J9.1, J9.2, J9.3, J9.4, J9.5, J9.6; also elsewhere on the board
/GPIO_BCD_A_0: J2.1, J2.2, R82.2; also elsewhere on the board
/GPIO_BCD_A_1: J3.1, J3.2, R86.2; also elsewhere on the board
/GPIO_BCD_B_0: J2.3, J2.4, R83.2; also elsewhere on the board
/GPIO_BCD_B_1: J3.3, J3.4, R87.2; also elsewhere on the board
/GPIO_BCD_C_0: J2.5, J2.6, R84.2; also elsewhere on the board
/GPIO_BCD_C_1: J3.5, J3.6, R88.2; also elsewhere on the board
/GPIO_BCD_D_0: J2.7, J2.8, R85.2; also elsewhere on the board
/GPIO_BCD_D_1: J3.7, J3.8, R89.2; also elsewhere on the board
/GPIO_LED_1: J4.1, J4.2, R74.2; also elsewhere on the board
/GPIO_LED_2: J4.3, J4.4, R75.2; also elsewhere on the board
/GPIO_LED_3: J4.5, J4.6, R76.2; also elsewhere on the board
/GPIO_LED_4: J4.7, J4.8, R77.2; also elsewhere on the board
/GPIO_LED_5: J4.9, J4.10, R78.2; also elsewhere on the board
/GPIO_LED_6: J4.11, J4.12, R79.2; also elsewhere on the board
/GPIO_LED_7: J4.13, J4.14, R80.2; also elsewhere on the board
/GPIO_LED_8: J4.15, J4.16, R81.2; also elsewhere on the board
/KEY0: J8.1, J8.2; also elsewhere on the board
/KEY1: J8.5, J8.6; also elsewhere on the board
/SEG_A_0: J5.1, J5.2; also elsewhere on the board
/SEG_A_1: J6.1, J6.2; also elsewhere on the board
/SEG_B_0: J5.3, J5.4; also elsewhere on the board
/SEG_B_1: J6.3, J6.4; also elsewhere on the board
/SEG_C_0: J5.5, J5.6; also elsewhere on the board
/SEG_C_1: J6.5, J6.6; also elsewhere on the board
/SEG_D_0: J5.7, J5.8; also elsewhere on the board
/SEG_D_1: J6.7, J6.8; also elsewhere on the board
/SEG_E_0: J5.9, J5.10; also elsewhere on the board
/SEG_E_1: J6.9, J6.10; also elsewhere on the board
/SEG_F_0: J5.11, J5.12; also elsewhere on the board
/SEG_F_1: J6.11, J6.12; also elsewhere on the board
/SEG_G_0: J5.13, J5.14; also elsewhere on the board
/SEG_G_1: J6.13, J6.14; also elsewhere on the board
/SW1: J7.1, J7.2; also elsewhere on the board
/SW2: J7.3, J7.4; also elsewhere on the board
/SW3: J7.5, J7.6; also elsewhere on the board
/SW4: J7.7, J7.8; also elsewhere on the board
/SW5: J7.9, J7.10; also elsewhere on the board
/SW6: J7.11, J7.12; also elsewhere on the board
/SW7: J7.13, J7.14; also elsewhere on the board
/SW8: J7.15, J7.16; also elsewhere on the board
/VCC5V: J10.1, J10.2, J10.3, J10.4, J10.5, J10.6, R82.1, R83.1, R84.1, R85.1, R86.1, R87.1, R88.1, R89.1; also elsewhere on the board
GND: J11.1, J11.2, J11.3, J11.4, J11.5, J11.6, R74.1, R75.1, R76.1, R77.1, R78.1, R79.1, R80.1, R81.1; also elsewhere on the board

Parts:
C5, C6, C9, C10, C12, C14: 0.1uF; C_0603_1608Metric; LCSC C14663
C7, C8, C11, C13: 22pF; C_0603_1608Metric; LCSC C1653
DS1: WC1602A
FB1, FB3, FB4, FB5: 80Ohm; FerriteBead; LCSC C141982
J1: USB-B; SAMTEC_USB-B-S-X-X-TH-TR
R0, R2, R3: 22; R_0603_1608Metric; LCSC C108405
R1: 1M; R_0603_1608Metric; LCSC C26098
R58: 220; R_0603_1608Metric; LCSC C22962
R59: 10k; R_0603_1608Metric; LCSC C98220
SW9: ButtonFirst; Button_CLOCK
TD0: SMF05C.TCT; SC70-6; LCSC C558425
TRIM0: Potentiometer; TRIM_3296W-1-501
U6: CH340G; SOIC-16_3.9x9.9mm_P1.27mm; LCSC C14267
U7: ICSP; PinHeader_2x03_P2.54mm_Vertical_SMD
U8, U10: 74HC165; SOIC-16_3.9x9.9mm_P1.27mm; LCSC C7742
U9, U11: 74HC595; SOIC-16_3.9x9.9mm_P1.27mm; LCSC C10092
U12: ATmega64A-AU; TQFP-64_14x14mm_P0.8mm; LCSC C9435
Y0: 16MHz; Crystal_SMD_Abracon_ABM3B-4Pin_5.0x3.2mm; LCSC C258963
Y1: 12MHz; Crystal_SMD_Abracon_ABM8G-4Pin_3.2x2.5mm; LCSC C258939

Connections:
/7SEGLED_TEST_OFF: U12.40 (PC5); also elsewhere on the board
/7SEGLED_TEST_ON: U12.39 (PC4); also elsewhere on the board
/ADJ_CLOCK: U12.61 (PF0); also elsewhere on the board
/BCD_A_0: U11.15 (QA); also elsewhere on the board
/BCD_A_1: U11.4 (QE); also elsewhere on the board
/BCD_B_0: U11.1 (QB); also elsewhere on the board
/BCD_B_1: U11.5 (QF); also elsewhere on the board
/BCD_C_0: U11.2 (QC); also elsewhere on the board
/BCD_C_1: U11.6 (QG); also elsewhere on the board
/BCD_D_0: U11.3 (QD); also elsewhere on the board
/BCD_D_1: U11.7 (QH); also elsewhere on the board
/CHANGE_CLK_SRC: U12.9 (PE7); also elsewhere on the board
/CLK_OUT: U12.17 (PB7); also elsewhere on the board
/DOWN_CLOCK: U12.26 (PD1); also elsewhere on the board
/GPIO_BCD_A_0: U10.11 (D0); also elsewhere on the board
/GPIO_BCD_A_1: U10.3 (D4); also elsewhere on the board
/GPIO_BCD_B_0: U10.12 (D1); also elsewhere on the board
/GPIO_BCD_B_1: U10.4 (D5); also elsewhere on the board
/GPIO_BCD_C_0: U10.13 (D2); also elsewhere on the board
/GPIO_BCD_C_1: U10.5 (D6); also elsewhere on the board
/GPIO_BCD_D_0: U10.14 (D3); also elsewhere on the board
/GPIO_BCD_D_1: U10.6 (D7); also elsewhere on the board
/GPIO_LED_1: U8.11 (D0); also elsewhere on the board
/GPIO_LED_2: U8.12 (D1); also elsewhere on the board
/GPIO_LED_3: U8.13 (D2); also elsewhere on the board
/GPIO_LED_4: U8.14 (D3); also elsewhere on the board
/GPIO_LED_5: U8.3 (D4); also elsewhere on the board
/GPIO_LED_6: U8.4 (D5); also elsewhere on the board
/GPIO_LED_7: U8.5 (D6); also elsewhere on the board
/GPIO_LED_8: U8.6 (D7); also elsewhere on the board
/LED1: U9.15 (QA); also elsewhere on the board
/LED2: U9.1 (QB); also elsewhere on the board
/LED3: U9.2 (QC); also elsewhere on the board
/LED4: U9.3 (QD); also elsewhere on the board
/LED5: U9.4 (QE); also elsewhere on the board
/LED6: U9.5 (QF); also elsewhere on the board
/LED7: U9.6 (QG); also elsewhere on the board
/LED8: U9.7 (QH); also elsewhere on the board
/MCU/D+: R3.1, U6.5 (UD+)
/MCU/D-: R2.1, U6.6 (UD-)
/MCU/IC_165_CTRL: U8.1 (~PL), U10.1 (~PL), U12.38 (PC3)
/MCU/IC_165_TO_MCU: U10.9 (Q7), U12.36 (PC1)
/MCU/IC_595_CTRL: U9.12 (RCLK), U11.12 (RCLK), U12.37 (PC2)
/MCU/IC_CLOCK: U8.2 (CP), U9.11 (SRCLK), U10.2 (CP), U11.11 (SRCLK), U12.41 (PC6)
/MCU/LCD_0: DS1.7 (D0), U12.58 (PF3)
/MCU/LCD_1: DS1.8 (D1), U12.57 (PF4)
/MCU/LCD_2: DS1.9 (D2), U12.56 (PF5)
/MCU/LCD_3: DS1.10 (D3), U12.55 (PF6)
/MCU/LCD_4: DS1.11 (D4), U12.54 (PF7)
/MCU/LCD_5: DS1.12 (D5), U12.51 (PA0)
/MCU/LCD_6: DS1.13 (D6), U12.50 (PA1)
/MCU/LCD_7: DS1.14 (D7), U12.49 (PA2)
/MCU/LCD_ENABLE: DS1.6 (E), U12.59 (PF2)
/MCU/LCD_RS: DS1.4 (RS), U12.60 (PF1)
/MCU/MCU_TO_IC_595: U9.14 (SER), U12.35 (PC0)
/MCU/MISO: U7.1 (MISO), U12.3 (PE1)
/MCU/MOSI: U7.4 (MOSI), U12.2 (PE0)
/MCU/RESET: C12.1, C14.1, R59.2, SW9.1, U7.5 (RST), U12.20 (~RESET)
/MCU/RXD: U6.2 (TXD), U12.27 (PD2)
/MCU/SCK: U7.3 (SCK), U12.11 (PB1)
/MCU/TXD: U6.3 (RXD), U12.28 (PD3)
/MCU/VBUS: FB3.1, TD0.1 (IO1)
/MCU/XI: C11.1, U6.7 (XI), Y1.1
/MCU/XO: C13.1, U6.8 (XO), Y1.3
/UP_CLOCK: U12.25 (PD0); also elsewhere on the board
/VCC5V: DS1.2 (VDD), FB1.1, FB4.1, FB5.1, R58.2, R59.1, TRIM0.1, U6.16 (VCC), U7.2 (VCC), U8.16 (VCC), U9.10 (~SRCLR), U9.16 (VCC), U10.16 (VCC), U11.10 (~SRCLR), U11.16 (VCC); also elsewhere on the board
GND: C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, DS1.1 (VSS), DS1.5 (R/W), DS1.16 (LED(-)), J1.4 (GND), R0.1, SW9.3, TD0.2 (GND), TRIM0.3, U6.1 (GND), U7.6 (GND), U8.8 (GND), U8.10 (DS), U8.15 (~CE), U9.8 (GND), U9.13 (~OE), U10.8 (GND), U10.15 (~CE), U11.8 (GND), U11.13 (~OE), U12.22 (GND), U12.53 (GND), U12.63 (GND), Y0.2 (GND), Y0.4 (GND), Y1.2 (GND), Y1.4 (GND); also elsewhere on the board
unnamed: C5.1, FB1.2, U12.62 (AREF)
unnamed: C6.1, U6.4 (V3)
unnamed: C7.1, R1.1, U12.24 (XTAL1), Y0.1
unnamed: C8.1, R1.2, U12.23 (XTAL2), Y0.3
unnamed: C9.1, FB4.2, U12.64 (AVCC)
unnamed: C10.1, FB5.2, U12.21 (VCC), U12.52 (VCC)
unnamed: C14.2, U6.13 (~DTR)
unnamed: DS1.3 (VO), TRIM0.2
unnamed: DS1.15 (LED(+)), R58.1
unnamed: FB3.2, J1.1 (VCC)
unnamed: J1.2 (D-), R2.2, TD0.6 (IO5)
unnamed: J1.3 (D+), R3.2, TD0.4 (IO3)
unnamed: J1.S1 (SHIELD), J1.S2 (SHIELD), R0.2
unnamed: U8.9 (Q7), U10.10 (DS)
unnamed: U9.9 (QH'), U11.14 (SER)
