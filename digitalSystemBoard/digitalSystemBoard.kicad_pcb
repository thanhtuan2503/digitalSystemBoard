# Repository thanhtuan2503/digitalSystemBoard (continued)

## KiCad design digitalSystemBoard/digitalSystemBoard.kicad_pcb (continued)

Board: 2 copper layers, 180.0 x 130.0 mm, 191 parts (0 on the bottom side), 172 nets.

File digitalSystemBoard/digitalSystemBoard_BOM.csv:

"Id";"Designator";"Package";"Quantity";"Designation";"Supplier and ref";
1;"PM0";"Power_Module";1;"Power_Module";;;
2;"REF**,REF**,REF**,REF**,REF**,REF**,REF**,REF**,REF**,REF**";"POWER_VIA";10;"POWER_VIA";;;
3;"U11,U9";"SOIC-16_3.9x9.9mm_P1.27mm";2;"74HC595";;;
4;"R89,R88,R87,R86,R85,R84,R83,R82,R81,R80,R79,R78,R77,R76,R75,R74,R58,R57,R56,R55,R54,R52,R53";"R_0603_1608Metric";23;"10k";;;
5;"TRIM0";"TRIM_3296W-1-501";1;"Potentiometer";;;
6;"R0";"R_0603_1608Metric";1;"220";;;
7;"LED0,LED1,LED2,LED3,LED4,LED5,LED6,LED7";"LED_3528";8;"LED";;;
8;"F0";"Fuse";1;"3A";;;
9;"SW0";"SS-12D11";1;"SW_SPDT";;;
10;"SW9";"Button_CLOCK";1;"ButtonFirst";;;
11;"KEY4,KEY3,KEY2,KEY0,KEY1";"Button";5;"ButtonFirst";;;
12;"Q15,Q14,Q13,Q12,Q11,Q10,Q9,Q8,Q7,Q6,Q5,Q4,Q3,Q2,Q1,Q0";"SO65P210X100-3N";16;"BC847";;;
13;"DS0";"WC1602A";1;"WC1602A";;;
14;"R73,R72,R71,R70,R69,R68,R67,R66,R65,R64,R63,R62,R61,R60";"R_0603_1608Metric";14;"330";;;
15;"U1,U0";"7SegmentLED_LTS6760_LTS6780";2;"KCSA02-105";;;
16;"J8,J11,J10,J9";"IDC-Header_2x03_P2.54mm_Vertical";4;"Conn_02x03_Odd_Even";;;
17;"U3,U2";"DIP_16_PIN_SOCKET";2;"74LS47";;;
18;"R13,R25,R22,R19,R16,R10,R7,R4";"R_0603_1608Metric";8;"15k";;;
19;"R15,R14,R27,R26,R24,R23,R21,R20,R18,R17,R12,R11,R9,R8,R6,R5";"R_0603_1608Metric";16;"2.49k";;;
20;"SW1,SW8,SW7,SW6,SW5,SW4,SW3,SW2";"SS-12F44G5";8;"IO_Switch";;;
21;"D4,D7,D6,D5,D3,D2,D1,D0";"LED_0603_1608Metric";8;"LED";;;
22;"R42,R51,R48,R45,R39,R36,R33,R30";"R_0603_1608Metric";8;"1.8k";;;
23;"R40,R49,R46,R43,R37,R34,R31,R28";"R_0603_1608Metric";8;"27k";;;
24;"R41,R50,R47,R44,R38,R35,R32,R29";"R_0603_1608Metric";8;"4.7k";;;
25;"J7,J4";"IDC-Header_2x08_P2.54mm_Vertical";2;"Conn_02x08_Odd_Even";;;
26;"J6,J5";"IDC-Header_2x07_P2.54mm_Vertical";2;"Conn_02x07_Odd_Even";;;
27;"J3,J2";"IDC-Header_2x04_P2.54mm_Vertical";2;"Conn_02x04_Odd_Even";;;
28;"J0";"BarrelJack_Horizontal";1;"Barrel_Jack";;;
29;"U7";"PinHeader_2x03_P2.54mm_Vertical_SMD";1;"ICSP";;;
30;"U5";"RV09S";1;"Potentiometer";;;
31;"H3,H2,H1,H0";"Mountinghole_M3";4;"MountingHole";;;
32;"Y0";"Crystal_SMD_Abracon_ABM3B-4Pin_5.0x3.2mm";1;"16MHz";;;
33;"U10,U8";"SOIC-16_3.9x9.9mm_P1.27mm";2;"74LS165";;;
34;"U6";"TQFP-44_10x10mm_P0.8mm";1;"ATmega32U4-AU";;;
35;"U4";"SOIC-14_3.9x8.7mm_P1.27mm";1;"74LS04";;;
36;"R59";"R_0603_1608Metric";1;"1M";;;
37;"R3,R2,R1";"R_0603_1608Metric";3;"22";;;
38;"J1";"SAMTEC_USB-B-S-X-X-TH-TR";1;"USB-B";;;
39;"FB5,FB4,FB3,FB2,FB1,FB0";"FerriteBead";6;"80Ohm";;;
40;"TD0";"SC70-6";1;"SMF05C.TCT";;;
41;"C12,C11,C10,C9,C8,C5,C4,C3,C2,C0,C1";"C_0603_1608Metric";11;"0.1uF";;;
42;"C7,C6";"C_0603_1608Metric";2;"22pF";;;

## KiCad design digitalSystemBoard/noname.kicad_pcb

Board: 2 copper layers, 173 parts (0 on the bottom side), 152 nets, no tracks yet.

Parts:
C1, C5, C6, C7, C8, C9, C12: 0.1uF; C_0603_1608Metric
C2: 100uF_C; CP_Elec_5x5.8
C3, C4: 10uF; C_0603_1608Metric
C10, C11: 22pF; C_0603_1608Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11: LED; LED_0805_2012Metric
D12, D13, D14, D15, D16, D17, D18, D19, D20, D21: LED; LED_3528
D22: SMF05C.TCT; SC70-6
DS1: WC1602A
F1: 2A; Fuse
FB1, FB2, FB3, FB4, FB5, FB6: 80Ohm; FerriteBead
J1: Barrel_Jack; BARREL_JACK
J2: OUTPUT_HEADER; PinHeader_2x10_P2.54mm_Vertical_SMD
J3: 7_LED_IN_2; PinHeader_2x07_P2.54mm_Vertical_SMD
J4: 7_LED_IN_1; PinHeader_2x07_P2.54mm_Vertical_SMD
J5: INPUT_HEADER; PinHeader_2x12_P2.54mm_Vertical_SMD
J6, J7: SN7447
J9: BCD_2; PinHeader_2x04_P2.54mm_Vertical_SMD
J10: BCD_1; PinHeader_2x04_P2.54mm_Vertical_SMD
J12: USB_OTG; SAMTEC_USB-B-S-X-X-TH-TR
J13: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical_SMD
Q1: MJD122T4G
Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q20, Q21: 2N7002; SO65P210X100-3N
R1, R3: 220; R_0603_1608Metric
R2: 0.22Ohm_5W; 5W_0.22R
R4, R5, R71, R72, R73, R74: 10K; R_0603_1608Metric
R6, R9, R12, R15, R18, R21, R24, R27, R30, R33, R36, R39, R42, R45, R48, R51, R54, R57, R60, R63: 10; R_0603_1608Metric
R7, R10, R13, R16, R19, R22, R25, R28, R31, R34, R37, R40, R43, R46, R49, R52, R55, R58, R61, R64, R70: 10k; R_0603_1608Metric
R8, R11, R14, R17, R20, R23, R26, R29, R32, R35: 470; R_0603_1608Metric
R38, R41, R44, R47, R50, R53, R56, R59, R62, R65: 330; R_0603_1608Metric
R66, R67, R68: 22; R_0603_1608Metric
R69: 1M; R_0603_1608Metric
SW1: SW_SPDT; SS-12D11
SW2, SW3, SW4, SW5, SW6, SW7: ButtonFirst; Button
U1: LM317
U2: Potentiometer; TRIM_3296W-1-501
U3: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
U5, U6, U7, U8, U9, U10, U11, U12, U13, U14: IO_Switch; SS-12F44G5
U15, U16: KCSA02-105; 7SegmentLED_LTS6760_LTS6780
U17: Potentiometer-digitalSystemBoard; RK09D117000B
U18: ICSP; PinHeader_2x03_P2.54mm_Vertical_SMD
Y1: 16MHz; Crystal_SMD_5032-4Pin_5.0x3.2mm

Connections:
+5V: C9.2, DS1.2, DS1.3, DS1.15, F1.2, FB1.1, FB2.1, FB3.1, FB4.1, FB6.1, R3.1, R4.1, R5.1, R8.1, R11.1, R14.1, R17.1, R20.1, R23.1, R26.1, R29.1, R32.1, R35.1, R38.1, R41.1, R44.1, R47.1, R50.1, R53.1, R56.1, R59.1, R62.1, R65.1, R70.1, R71.1, R72.1, R73.1, U5.3, U6.3, U7.3, U8.3, U9.3, U10.3, U11.3, U12.3, U13.3, U14.3, U17.1, U18.1
/A1: J7.4, J10.1, J10.2
/A2: J6.4, J9.1, J9.2
/A_J: J3.13, J3.14, J6.13, U15.7
/A_X: J4.13, J4.14, J7.13, U16.7
/B1: J7.16, J10.3, J10.4
/B2: J6.16, J9.3, J9.4
/BI_RBO: J6.10, J7.10
/B_J: J3.11, J3.12, J6.11, U15.6
/B_X: J4.11, J4.12, J7.11, U16.6
/C1: J7.14, J10.5, J10.6
/C2: J6.14, J9.5, J9.6
/CLK_OUT: J13.1, J13.2, J13.3, J13.4, J13.5, J13.6, U3.29
/CLOCK_GENERATOR/CHANGE_CLK_SRC: R73.2, SW7.1, U3.19
/CLOCK_GENERATOR/CLOCK_WHEEL: U3.36, U17.2
/CLOCK_GENERATOR/D0: DS1.7, U3.30
/CLOCK_GENERATOR/D1: DS1.8, U3.31
/CLOCK_GENERATOR/D2: DS1.9, U3.32
/CLOCK_GENERATOR/D3: DS1.10, U3.41
/CLOCK_GENERATOR/D4: DS1.11, U3.40
/CLOCK_GENERATOR/D5: DS1.12, U3.39
/CLOCK_GENERATOR/D6: DS1.13, U3.38
/CLOCK_GENERATOR/D7: DS1.14, U3.37
/CLOCK_GENERATOR/D+: R66.1, U3.4
/CLOCK_GENERATOR/D-: R67.1, U3.3
/CLOCK_GENERATOR/DOWN_CLK: R72.2, SW6.1, U3.20
/CLOCK_GENERATOR/LCD_ENABLE: DS1.6, U3.28
/CLOCK_GENERATOR/MISO: U3.11, U18.4
/CLOCK_GENERATOR/MOSI: U3.10, U18.3
/CLOCK_GENERATOR/RS: DS1.4, U3.27
/CLOCK_GENERATOR/RST: R70.2, SW4.1, U3.13, U18.5
/CLOCK_GENERATOR/SCK: U3.9, U18.6
/CLOCK_GENERATOR/UP_CLK: R71.2, SW5.1, U3.21
/CLOCK_GENERATOR/VBUS: FB5.2, U3.7
/C_J: J3.9, J3.10, J6.9, U15.4
/C_X: J4.9, J4.10, J7.9, U16.4
/D1: J7.6, J10.7, J10.8
/D2: J6.6, J9.7, J9.8
/D_J: J3.7, J3.8, J6.7, U15.2
/D_X: J4.7, J4.8, J7.7, U16.2
/E_J: J3.5, J3.6, J6.5, U15.1
/E_X: J4.5, J4.6, J7.5, U16.1
/F_J: J3.3, J3.4, J6.3, U15.9
/F_X: J4.3, J4.4, J7.3, U16.9
/G_J: J3.1, J3.2, J6.1, U15.10
/G_X: J4.1, J4.2, J7.1, U16.10
/IB1: J5.3, J5.4, R4.2, SW2.3
/IB2: J5.1, J5.2, R5.2, SW3.3
/LT: J6.12, J7.12
/O1: J5.23, J5.24, R6.2, U5.2
/O2: J5.21, J5.22, R9.2, U6.2
/O3: J5.19, J5.20, R12.2, U7.2
/O4: J5.17, J5.18, R15.2, U8.2
/O5: J5.15, J5.16, R18.2, U9.2
/O6: J5.13, J5.14, R21.2, U10.2
/O7: J5.11, J5.12, R24.2, U11.2
/O8: J5.9, J5.10, R27.2, U12.2
/O9: J5.7, J5.8, R30.2, U13.2
/O10: J5.5, J5.6, R33.2, U14.2
/OLED1: J2.1, J2.2, R36.2
/OLED2: J2.3, J2.4, R39.2
/OLED3: J2.5, J2.6, R42.2
/OLED4: J2.7, J2.8, R45.2
/OLED5: J2.9, J2.10, R48.2
/OLED6: J2.11, J2.12, R51.2
/OLED7: J2.13, J2.14, R54.2
/OLED8: J2.15, J2.16, R57.2
/OLED9: J2.17, J2.18, R60.2
/OLED10: J2.19, J2.20, R63.2
/RBI: J6.8, J7.8
/VCC: J6.15, J7.15
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.1, C10.1, C11.1, C12.2, D1.1, D22.2, DS1.1, DS1.5, DS1.16, J1.2, J6.2, J7.2, J12.4, Q2.2, Q3.2, Q4.2, Q5.2, Q6.2, Q7.2, Q8.2, Q9.2, Q10.2, Q11.2, Q12.2, Q13.2, Q14.2, Q15.2, Q16.2, Q17.2, Q18.2, Q19.2, Q20.2, Q21.2, R7.2, R10.2, R13.2, R16.2, R19.2, R22.2, R25.2, R28.2, R31.2, R34.2, R37.2, R40.2, R43.2, R46.2, R49.2, R52.2, R55.2, R58.2, R61.2, R64.2, R68.1, R74.2, SW2.1, SW3.1, SW4.3, SW5.3, SW6.3, SW7.3, U2.1, U3.5, U3.15, U3.23, U3.35, U3.43, U15.3, U15.8, U16.3, U16.8, U18.2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
unnamed: C1.1, Q1.2, SW1.3, U1.3
unnamed: C2.1, C3.1, Q1.1, R1.1, U1.2
unnamed: C4.1, F1.1, R2.2
unnamed: C5.1, FB1.2, U3.2
unnamed: C6.1, FB2.2, U3.14, U3.34
unnamed: C7.1, FB3.2, U3.24, U3.44
unnamed: C8.1, FB4.2, U3.6
unnamed: C10.2, R69.2, U3.16, Y1.3
unnamed: C11.2, R69.1, U3.17, Y1.1
unnamed: C12.1, FB6.2, U3.42
unnamed: D1.2, R3.2
unnamed: D2.1, Q2.3
unnamed: D2.2, R8.2
unnamed: D3.1, Q3.3
unnamed: D3.2, R11.2
unnamed: D4.1, Q4.3
unnamed: D4.2, R14.2
unnamed: D5.1, Q5.3
unnamed: D5.2, R17.2
unnamed: D6.1, Q6.3
unnamed: D6.2, R20.2
unnamed: D7.1, Q7.3
unnamed: D7.2, R23.2
unnamed: D8.1, Q8.3
unnamed: D8.2, R26.2
unnamed: D9.1, Q9.3
unnamed: D9.2, R29.2
unnamed: D10.1, Q10.3
unnamed: D10.2, R32.2
unnamed: D11.1, Q11.3
unnamed: D11.2, R35.2
unnamed: D12.1, Q12.3
unnamed: D12.2, R38.2
unnamed: D13.1, Q13.3
unnamed: D13.2, R41.2
unnamed: D14.1, Q14.3
unnamed: D14.2, R44.2
unnamed: D15.1, Q15.3
unnamed: D15.2, R47.2
unnamed: D16.1, Q16.3
unnamed: D16.2, R50.2
unnamed: D17.1, Q17.3
unnamed: D17.2, R53.2
unnamed: D18.1, Q18.3
unnamed: D18.2, R56.2
unnamed: D19.1, Q19.3
unnamed: D19.2, R59.2
unnamed: D20.1, Q20.3
unnamed: D20.2, R62.2
unnamed: D21.1, Q21.3
unnamed: D21.2, R65.2
unnamed: D22.4, J12.2, R67.2
unnamed: D22.6, J12.3, R66.2
unnamed: FB5.1, J12.1
unnamed: J1.1, SW1.2
unnamed: J12.S1, J12.S2, R68.2
unnamed: Q1.3, R2.1
unnamed: Q2.1, R6.1, R7.1
unnamed: Q3.1, R9.1, R10.1
unnamed: Q4.1, R12.1, R13.1
unnamed: Q5.1, R15.1, R16.1
unnamed: Q6.1, R18.1, R19.1
unnamed: Q7.1, R21.1, R22.1
unnamed: Q8.1, R24.1, R25.1
unnamed: Q9.1, R27.1, R28.1
unnamed: Q10.1, R30.1, R31.1
unnamed: Q11.1, R33.1, R34.1
unnamed: Q12.1, R36.1, R37.1
unnamed: Q13.1, R39.1, R40.1
unnamed: Q14.1, R42.1, R43.1
unnamed: Q15.1, R45.1, R46.1
unnamed: Q16.1, R48.1, R49.1
unnamed: Q17.1, R51.1, R52.1
unnamed: Q18.1, R54.1, R55.1
unnamed: Q19.1, R57.1, R58.1
unnamed: Q20.1, R60.1, R61.1
unnamed: Q21.1, R63.1, R64.1
unnamed: R1.2, U2.2
unnamed: R74.1, U3.33
unnamed: U1.1, U2.3

## Commit log

2020-10-13 Upload file
2020-10-13 add footprint library
2020-10-13 Upload footprint file
2020-10-13 Add footprint A
2020-10-13 Upload led file
2020-10-13 Push footprint of button
2020-10-14 Add footprint: RV09S - Swicth
2020-10-14 Upload schematic lib
2020-10-14 Upload Schematic of Board
2020-10-15 Complete Output Block
2020-10-15 Update footprints and CLOCK_BLOCK Sch
2020-10-17 Upload Timer Block
2020-10-18 Redesign CLOCK_GENERATOR and add footprints for LM317, 5W resistor
2020-10-19 Update a part of footprint
2020-10-19 Upload schematic full agan
2020-10-19 Upload all footprint
2020-10-20 Change PCB
2020-10-20 Upload PCB footprint
2020-10-20 Fixed Error
2020-10-20 Upload after error
2020-10-20 Prepare for PCB
2020-10-20 Start to place component
2020-10-21 Add usb source block
2020-10-21 Update board layout
2020-10-21 Add all footprints of usb source block
2020-10-21 Add fb and smfc frpt
2020-10-21 ready for pull
2020-10-21 Ready for commit after update
2020-10-23 Update I/O and MCU schematic
2020-10-24 Update I/O schematic, Complete layout, Start routing
2020-10-26 Hot fix schematics. Update MCU layout
2020-10-29 Update new layout, add power vias
2020-10-29 Define track
2020-10-30 add libs'
2020-11-10 Hot fix Libs. Update schematic
2020-11-25 Update new schematic.
2020-11-25 Change grid size to 10mils and wire components in power supply and display sheet
2020-12-02 Change grid size of all schematic
2020-12-03 Update Schematic for review
2020-12-03 Change file xlsx
2020-12-03 Review schematic and change pin in slide switch
2020-12-03 Edit after review
2020-12-04 Add footprint
2020-12-05 Add full footprint. Draw layout board
2020-12-06 Edit footprint
2020-12-06 Update layout
2020-12-06 Update Layout 2
2020-12-06 Layout power block
2020-12-07 Layout element
2020-12-08 Layout 70 percent board
2020-12-08 Edit LCD footprint
2020-12-08 Add net for ICSP and USB
2020-12-08 Resize board
2020-12-08 Switch Connected
2020-12-09 LCD connected
2020-12-09 Ready for power line wiring
2020-12-09 power line start wiring
2020-12-09 finish wiring
2020-12-09 pour cu
2020-12-09 added pin map
2020-12-10 Hot fix: added resistors for ic 7447
2020-12-10 Hot fix: modifiy LCD footprint
2020-12-10 Hot fix: move fuse
2020-12-12 add boardcuts, origins
2020-12-12 export Gerber files for production
2020-12-12 resize gnd line
2020-12-12 Hot fix: change symbol and footprint of the barrell jack
2020-12-12 re-route power line, reset origin
2020-12-12 re-route power line and re-pour poly and reset origin
2020-12-12 fabrication output 1.0.1
2020-12-25 Hot fix: Change footprint. Fix power schematic.
2020-12-28 Debug error of schematic.
2020-12-31 Debug error part 2
2021-01-04 Final debug footprints error
2021-01-04 Hot fix: edited power switch and button footprint
2021-01-04 Add fill zone layer
2021-01-14 Hot fix: Modify Reset button footprint
2021-01-23 update F_Silk
2021-01-23 export gerber 1.0.2
2021-01-26 Edit BJT BC847 References
2021-01-26 Modify Power switch and Fuse footprints
2021-01-27 Add discharge resistor for power block
2021-01-27 Pour front copper layer
2021-01-27 Modify LED 3528 footprint.
2021-01-31 Add keepout areas for Power Block. Modify 7-segment LED schematic
2021-02-22 Add resistor 16P8R
2021-03-01 Pull Up/Down Led
2021-03-03 Fix bug in BCD, add an rheostat on Vo and add an resistor on LED+
2021-03-04 Reroute VCC5V line
2021-03-16 Replace R array by 16 single R
2021-04-01 Add IC 74HC595 and R for input pin
2021-04-01 Edit ground wire
2021-05-07 Add Power_Module symbol and footprint
2021-05-07 Add Power_module to schematic and pcb
2021-05-07 Soldermask
2021-05-08 Fix name of all device
2021-05-08 Update voltage bias for LED green and LED yellow
2021-05-08 Move U3 name
2021-05-09 Modify Power_Module footprint
2021-05-09 Change drill hole size for Power_Module
2021-05-10 Add BOM file and CPL file
2021-05-10 Ready for generate Bom file and CPL file
2021-05-10 Check before SMT
2021-05-11 Modify CPL and BOM file
2021-05-11 Fabrication output ver 2.0.1
2021-05-11 Update BOM and CPL for order
2021-05-11 Adding ver2.0.2
2021-06-01 Synchronize the name of all the device
2021-06-01 Fix footprint of LED and Button
2021-06-04 Add new footprint for led and button reset again
2021-06-10 Change part for R47K and C22pF
2021-06-10 Fix error un similar between schematic and jlc
2021-06-16 Fix small bug
2021-06-16 Add 3d symbol for power module!
2021-06-20 Create ordered folder
2021-06-27 Fix U9 and Led0 display
2021-07-01 Change part of crystal
2021-10-18 Add link gg drive Chi Phi
2021-11-13 Update MCU to ATmega64A
2021-11-14 Update file Gerber, CPL and BOM
2021-11-14 Update LED footprint
2021-11-29 Debug the MISO, MOSI, TXD, RXD and INT2 route
2021-12-03 Add gerber file
2021-12-24 add plastic cover design
2021-12-27 Add LCD 3D model
2021-12-27 edit LCD 3d
2022-01-05 Update USB and Fuse model
2022-01-05 Update Switch 3D model
2022-01-05 Update SW model
2022-01-05 Save project :)))
2022-01-05 Update reset button model
2022-01-05 Update PowerSwitch, Rheostat and Socket 3D model
2022-01-05 Update power module and button model
2022-01-05 Update power module and IC 3D model
2022-01-05 Update transistor and ferite 3d model
2022-01-30 Add readme file.
2022-01-30 Fix picture in readme file.
2022-01-30 Adding readme file for TICKIT 1.0
2022-01-30 Renew pull request
2022-01-30 Save to KiCad 6
